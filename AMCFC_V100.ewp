# IAR project AMCFC_V100.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Sources\CPU\H; Sources\Drivers\H; Sources\Project\H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AMCFC_V100.srec
  ILINK.IlinkOutputFile: AMCFC_V100.out
  ILINK.IlinkIcfFile: Link\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: Sources\CPU\H; Sources\DRIVERS\H; Sources\PROJECT\H
  ILINK.IlinkIcfFile: F:\K60 works\AMCFC_V100\Link\Ram.icf
  group Link
    Link/: Pflash.icf Ram.icf
  group Sources/CPU/C
    Sources/CPU/C/: common.c sysinit.c vectors.c
  group Sources/CPU/H
    Sources/CPU/H/: common.h MK60N512VMD100.h sysinit.h vectors.h
  group Sources/Drivers/C
    Sources/Drivers/C/: adc.c ftm.c gpio.c i2c.c pit.c uart.c wdog.c
  group Sources/Drivers/H
    Sources/Drivers/H/: adc.h ftm.h gpio.h i2c.h pit.h uart.h wdog.h
  group Sources/Project/C
    Sources/Project/C/: imu.c isr.c light.c main.c ppm.c sensors.c
  group Sources/Project/H
    Sources/Project/H/: imu.h includes.h light.h ppm.h sensors.h
  group Startup
    Startup/: crt0.s start.c
